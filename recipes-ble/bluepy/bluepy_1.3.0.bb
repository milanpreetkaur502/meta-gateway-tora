
require bluepy.inc

PV = "1.3.0"
SRCREV = "${AUTOREV}"
